# Repository Adesin-fr/KicadDomo

## KiCad design mySensors_1Relay/mySensors_1Relay.kicad_pcb

Board: 2 copper layers, 42.5 x 50.0 mm, 16 parts (2 on the bottom side), 19 nets.

Parts:
C1, C2: 10uF; C_1206_HandSoldering
D1: D; D_SOD-123
IC1: ATMEGA328-A; TQFP-32_7x7mm_Pitch0.8mm
IN: CONN_01X02; bornier2
OUT: CONN_01X03; bornier3
P1: 220V; bornier2
P2: ANT; Pin_Header_Straight_1x01_Pitch2.54mm
P3: CONN_02X03; Pin_Header_Straight_2x03_Pitch2.54mm
Q1: MBT2222; SOT-23
R1: 390; R_1206_HandSoldering
R2: 10k; R_1206_HandSoldering
RLY1: SRD_Type_C; SRD_Relay_TypeC
U1: AMS1117; SOT-223
U2: RFM69HW; RFM69HW_SMD_Handsoldering
U3: HLK-PM01

Connections:
/3V3: C2.1, IC1.4, IC1.6, P3.2, R2.2, U1.2, U2.8
/CS: IC1.14, R2.1, U2.15
/GND: C1.2, C2.2, IC1.3, IC1.5, IC1.21, IN.2, P3.6, Q1.3, U1.1, U2.9, U2.11, U3.4
/IRQ: IC1.32, U2.2
/MISO: IC1.16, P3.1, U2.13
/MOSI: IC1.15, P3.4, U2.14
/RESET: IC1.29, P3.5
/S0: D1.2, Q1.2, RLY1.2
/SCK: IC1.17, P3.3, U2.12
/SL0: IC1.31, R1.2
/VCC: C1.1, D1.1, RLY1.1, U1.3, U3.3
unnamed: IC1.11, IN.1
unnamed: P1.1, U3.1
unnamed: P1.2, U3.2
unnamed: P2.1, U2.10
unnamed: OUT.1, RLY1.3
unnamed: OUT.2, RLY1.5
unnamed: OUT.3, RLY1.4
unnamed: Q1.1, R1.1

## KiCad design MultiUse_Battery_RFM69HCW/MultiUse_Battery_RFM69HCW.kicad_pcb

Parts:
3VIN1: CONN_01X02; Pin_Header_Straight_1x02_Pitch2.54mm
ANT1: CONN_01X01; Pin_Header_Straight_1x01
C1: 100nF; C_1206_HandSoldering
C2: 10uF; C_1206_HandSoldering
IC1: ATMEGA328P-AU; TQFP-32_7x7mm_Pitch0.8mm
ICSP1: CONN_02X03; Pin_Header_Straight_2x03
JP1: Jumper; Jump
P1: CONN_01X02; BU2032_smd
R1, R2: 4K7; R_1206_HandSoldering
S1, S2: CONN_01X03; Pin_Header_Straight_1x03_Pitch2.54mm
U1: RFM69HCW; RFM69HCW_HandSolder
U2: AP111733; SOT-223

Connections:
/3V3: C1.1, C2.1, IC1.4 (VCC), IC1.6 (VCC), IC1.18 (AVCC), IC1.20 (AREF), ICSP1.2, R1.1, R2.1, S1.1, S2.1, U1.13 (3.3V), U2.2 (VO), U2.4 (VO)
/CE: IC1.13 ((PCINT1/OC1A)PB1)
/CSN: IC1.14 ((PCINT2/OC1B/~SS~)PB2), U1.5 (NSS)
/GND: 3VIN1.2, C1.2, C2.2, IC1.3 (GND), IC1.5 (GND), IC1.21 (GND), ICSP1.6, P1.2, S1.3, S2.3, U1.1 (GND), U1.8 (GND), U1.10 (GND), U2.1 (GND/ADJ)
/IRQ: IC1.32 ((PCINT18/INT0)PD2), U1.14 (DIO0)
/MISO: IC1.16 ((PCINT4/MISO)PB4), ICSP1.1, U1.2 (MISO)
/MOSI: IC1.15 ((PCINT3/OC2A/MOSI)PB3), ICSP1.4, U1.3 (MOSI)
/PC0: IC1.24 ((PCINT9/ADC1)PC1), R1.2, S1.2
/PC1: IC1.23 ((PCINT8/ADC0)PC0), R2.2, S2.2
/RST: IC1.29 ((PCINT14/~RESET~)PC6), ICSP1.5
/SCK: IC1.17 ((PCINT5/SCK)PB5), ICSP1.3, U1.4 (SCK)
/VBAT: IC1.28 ((PCINT13/SCL/ADC5)PC5)
/VIN: 3VIN1.1, P1.1, U2.3 (VI)
unnamed: ANT1.1, U1.9 (ANA)

Board: 2 copper layers, 49.0 x 24.0 mm, 13 parts (1 on the bottom side), 12 nets.

## KiCad design MySensors_Gateway/MySensors_Gateway.kicad_pcb

Parts:
C1, C2: C; C_Radial_D5_L6_P2.5
D1, D2, D3: LED; LED-3MM
P1: CONN_01X01; Pin_Header_Straight_1x01_Pitch2.54mm
P2, P3: CONN_01X02; Pin_Header_Straight_1x02_Pitch2.54mm
R1, R2, R3: R; R_1206_HandSoldering
U1: AP111733; SOT-223
U2: arduino_mini
U3: RFM69HW; RFM69HW_SMD_Handsoldering
U4: 74HC245; SOIC-20W_7.5x12.8mm_Pitch1.27mm

Connections:
/CS: U2.28 ((SS)#D10), U4.4 (A2)
/CS3: U3.15 (NSS), U4.16 (B2)
/IRQ: U2.20 ((int2)D2), U3.2 (DIO0)
/LED_ERR: R3.2, U2.6 (A2)
/LED_RX: R2.2, U2.5 (A1)
/LED_TX: R1.2, U2.4 (A0)
/MISO: U2.30 ((MISO)D12), U4.15 (B3)
/MISO3: U3.13 (MISO), U4.5 (A3)
/MOSI: U2.29 ((MOSI)#D11), U4.3 (A1)
/MOSI3: U3.14 (MOSI), U4.17 (B1)
/SCK: U2.1 ((led)(SCK)D13), U4.2 (A0)
/SCK3: U3.12 (SCK), U4.18 (B0)
/VUSB: C1.1, P2.1, U1.3 (VI), U2.12 (5V)
GND: C1.2, C2.2, D1.1 (K), D2.1 (K), D3.1 (K), P2.2, P3.1, U1.1 (GND/ADJ), U2.14 (GND), U2.19 (GND), U3.9 (GND), U3.11 (GND), U4.10 (GND), U4.19 (CE)
unnamed: D1.2 (A), R1.1
unnamed: D2.2 (A), R2.1
unnamed: D3.2 (A), R3.1
unnamed: P1.1, U3.10 (ANA)
VCC: C2.1, P3.2, U1.2 (VO), U1.4 (VO), U3.8 (3.3V), U4.1 (A->B), U4.20 (VCC)

Board: 2 copper layers, 64.0 x 34.0 mm, 15 parts (1 on the bottom side), 19 nets.

## KiCad design mySensors_Teleinfo/mySensors_Teleinfo.kicad_pcb

Parts:
C1: 2200u; C_Radial_D10_L20_P5
C3: 1u; C_1206_HandSoldering
D1: MB6S; TO-269AA
IC1: ATMEGA328-A; TQFP-32_7x7mm_Pitch0.8mm
P1: CONN_01X02; bornier2
P2: ICSP; Pin_Header_Straight_2x03_Pitch2.54mm
P3: ANT; Pin_Header_Straight_1x02_Pitch2.54mm
R1: 1k2; R_1206_HandSoldering
R2: 4k7; R_1206_HandSoldering
U1: SFH620; DIP-4_W7.62mm_SMD
U3: AMS1117; SOT-223
U4: RFM69HW; RFM69HW_SMD_Handsoldering

Connections:
/3V3: C3.1, IC1.4 (VCC), IC1.6 (VCC), P2.2, R2.1, U3.2 (VO), U4.8 (3.3V)
/CS: IC1.14 ((PCINT2/OC1B/~SS~)PB2), U4.15 (NSS)
/GND: C1.2, C3.2, D1.4 (-), IC1.3 (GND), IC1.5 (GND), IC1.21 (GND), P2.6, P3.1, U1.3, U3.1 (GND), U4.9 (GND), U4.11 (GND)
/IRQ: IC1.32 ((PCINT18/INT0)PD2), U4.2 (DIO0)
/MISO: IC1.16 ((PCINT4/MISO)PB4), P2.1, U4.13 (MISO)
/MOSI: IC1.15 ((PCINT3/OC2A/MOSI)PB3), P2.4, U4.14 (MOSI)
/RESET: IC1.29 ((PCINT14/~RESET~)PC6), P2.5
/SCK: IC1.17 ((PCINT5/SCK)PB5), P2.3, U4.12 (SCK)
/T+: D1.1, P1.2, R1.2
/T-: D1.2, P1.1, U1.2
/T_IN: IC1.30 ((PCINT16/RXD)PD0), R2.2, U1.4
/VIN: C1.1, D1.3 (+), U3.3 (VI)
unnamed: P3.2, U4.10 (ANA)
unnamed: R1.1, U1.1

Board: 2 copper layers, 27.5 x 74.5 mm, 12 parts (0 on the bottom side), 14 nets.

## KiCad design mySensors_8RelaisReed/mySensors_8RelaisReed.kicad_pcb

Parts:
C1, C2: 10uF; C_Radial_D5_L6_P2.5
D1, D2, D3, D4, D5, D6, D7, D8: D; SOD-123
IC1: ATMEGA328-A; TQFP-32_7x7mm_Pitch0.8mm
P1: 5VIN; bornier2
P2: ANT; Pin_Header_Straight_1x01_Pitch2.54mm
P3: CONN_02X03; Pin_Header_Straight_2x03_Pitch2.54mm
P4, P5, P6, P7, P8, P9, P10, P11: CONN_01X02; bornier2
R1, R2, R3, R4, R5, R6, R7, R8: RELAY_SIP-1A05; SIP4_5.08
R9: 10k; R_1206_HandSoldering
U1: AMS1117; SOT-223
U2: RFM69HW; RFM69HW_SMD_Handsoldering
U3: 74HC595; SO-16-N

Connections:
/3V3: C2.1, IC1.4 (VCC), IC1.6 (VCC), P3.2, R9.1, U1.2 (VO), U2.8 (3.3V)
/CS: IC1.14 ((PCINT2/OC1B/~SS~)PB2), R9.2, U2.15 (NSS)
/IRQ: IC1.32 ((PCINT18/INT0)PD2), U2.2 (DIO0)
/MISO: IC1.16 ((PCINT4/MISO)PB4), P3.1, U2.13 (MISO)
/MOSI: IC1.15 ((PCINT3/OC2A/MOSI)PB3), P3.4, U2.14 (MOSI)
/RCLK: IC1.24 ((PCINT9/ADC1)PC1), U3.12 (RCLK)
/RESET: IC1.29 ((PCINT14/~RESET~)PC6), P3.5
/S0: D1.1 (K), R1.1 (COIL_A), U3.7 (QH)
/S1: D2.1 (K), R2.1 (COIL_A), U3.6 (QG)
/S2: D3.1 (K), R3.1 (COIL_A), U3.5 (QF)
/S3: D4.1 (K), R4.1 (COIL_A), U3.4 (QE)
/S4: D5.1 (K), R5.1 (COIL_A), U3.3 (QD)
/S5: D6.1 (K), R6.1 (COIL_A), U3.2 (QC)
/S6: D7.1 (K), R7.1 (COIL_A), U3.1 (QB)
/S7: D8.1 (K), R8.1 (COIL_A), U3.15 (QA)
/SCK: IC1.17 ((PCINT5/SCK)PB5), P3.3, U2.12 (SCK)
/SER: IC1.23 ((PCINT8/ADC0)PC0), U3.14 (SER)
/SRCLK: IC1.25 ((PCINT10/ADC2)PC2), U3.11 (SRCLK)
GND: C1.2, C2.2, D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), IC1.3 (GND), IC1.5 (GND), IC1.21 (GND), P1.1, P3.6, R1.4 (COIL_B), R2.4 (COIL_B), R3.4 (COIL_B), R4.4 (COIL_B), R5.4 (COIL_B), R6.4 (COIL_B), R7.4 (COIL_B), R8.4 (COIL_B), U1.1 (GND), U2.9 (GND), U2.11 (GND), U3.8 (GND), U3.13 (G)
unnamed: P2.1, U2.10 (ANA)
unnamed: P4.1, R1.2 (CONT_B)
unnamed: P4.2, R1.3 (CONT_A)
unnamed: P5.1, R2.2 (CONT_B)
unnamed: P5.2, R2.3 (CONT_A)
unnamed: P6.1, R3.2 (CONT_B)
unnamed: P6.2, R3.3 (CONT_A)
unnamed: P7.1, R4.2 (CONT_B)
unnamed: P7.2, R4.3 (CONT_A)
unnamed: P8.1, R5.2 (CONT_B)
unnamed: P8.2, R5.3 (CONT_A)
unnamed: P9.1, R6.2 (CONT_B)
unnamed: P9.2, R6.3 (CONT_A)
unnamed: P10.1, R7.2 (CONT_B)
unnamed: P10.2, R7.3 (CONT_A)
unnamed: P11.1, R8.2 (CONT_B)
unnamed: P11.2, R8.3 (CONT_A)
VCC: C1.1, P1.2, U1.3 (VI), U3.10 (SRCLR), U3.16 (VCC)

Board: 2 copper layers, 81.3 x 59.7 mm, 34 parts (0 on the bottom side), 37 nets.

## KiCad design mySensors_2Relais/mySensors_2Relais.kicad_pcb

Board: 2 copper layers, 56.0 x 57.0 mm, 20 parts (1 on the bottom side), 26 nets.

Parts:
390, 390#2: R; R_1206_HandSoldering
ANT: ANT; Pin_Header_Straight_1x01_Pitch2.54mm
C1, C2: 10uF; C_1206_HandSoldering
D1, D2: D; D_SOD-123
IC1: ATMEGA328-A; TQFP-32_7x7mm_Pitch0.8mm
ICSP: CONN_02X03; Pin_Header_Straight_2x03_Pitch2.54mm
IN1   IN2   COM: bornier3
P1: CONN_01X02; bornier2
P4, P5: bornier3
Q1, Q2: PZT2222A; SOT-23
RLY1, RLY2: SRD_Type_C; SRD_Relay_TypeC
U1: AMS1117; SOT-223
U2: RFM69HW; RFM69HW_SMD_Handsoldering
U3: HLK-PM01

Connections:
/3V3: C2.1, IC1.4, IC1.6, ICSP.2, U1.2, U2.8
/CS: IC1.14, U2.15
/GND: C1.2, C2.2, IC1.3, IC1.5, IC1.21, ICSP.6, IN1 IN2 COM.3, Q1.3, Q2.3, U1.1, U2.9, U2.11, U3.4
/IRQ: IC1.32, U2.2
/MISO: IC1.16, ICSP.1, U2.13
/MOSI: IC1.15, ICSP.4, U2.14
/RESET: IC1.29, ICSP.5
/S0: D1.2, Q1.2, RLY1.2
/S1: D2.2, Q2.2, RLY2.2
/SCK: IC1.17, ICSP.3, U2.12
/SL0: 390.2, IC1.31
/SL1: 390#2.2, IC1.30
/VCC: C1.1, D1.1, D2.1, RLY1.1, RLY2.1, U1.3, U3.3
unnamed: IC1.10, IN1 IN2 COM.1
unnamed: IC1.11, IN1 IN2 COM.2
unnamed: P1.1, U3.1
unnamed: P1.2, U3.2
unnamed: ANT.1, U2.10
unnamed: P4.1, RLY1.4
unnamed: P4.2, RLY1.5
unnamed: P4.3, RLY1.3
unnamed: P5.1, RLY2.4
unnamed: P5.2, RLY2.5
unnamed: P5.3, RLY2.3
unnamed: 390.1, Q1.1
unnamed: 390#2.1, Q2.1

## KiCad design mySensors_8Relais/mySensors_8Relais.kicad_pcb

Parts:
C1, C2: 10uF; C_Radial_D5_L6_P2.5
IC1: ATMEGA328-A; TQFP-32_7x7mm_Pitch0.8mm
IC2: ULN2803A; SOIC-18W_7.5x11.6mm_Pitch1.27mm
P1: 5VIN; bornier2
P2: ANT; Pin_Header_Straight_1x01_Pitch2.54mm
P3: CONN_02X03; Pin_Header_Straight_2x03_Pitch2.54mm
P4, P5, P6, P7, P8, P9, P10, P11: CONN_01X03; bornier3
RLY1, RLY2, RLY3, RLY4, RLY5, RLY6, RLY7, RLY8: SRD_Type_C; SRD_Relay_TypeC
U1: AMS1117; SOT-223
U2: RFM69HW; RFM69HW_SMD_Handsoldering

Connections:
/3V3: C2.1, IC1.4 (VCC), IC1.6 (VCC), P3.2, U1.2 (VO), U2.8 (3.3V)
/CS: IC1.14 ((PCINT2/OC1B/~SS~)PB2), U2.15 (NSS)
/GND: C1.2, C2.2, IC1.3 (GND), IC1.5 (GND), IC1.21 (GND), IC2.9 (GND), P1.1, P3.6, U1.1 (GND), U2.9 (GND), U2.11 (GND)
/IRQ: IC1.32 ((PCINT18/INT0)PD2), U2.2 (DIO0)
/MISO: IC1.16 ((PCINT4/MISO)PB4), P3.1, U2.13 (MISO)
/MOSI: IC1.15 ((PCINT3/OC2A/MOSI)PB3), P3.4, U2.14 (MOSI)
/RESET: IC1.29 ((PCINT14/~RESET~)PC6), P3.5
/S0: IC2.18 (O1), RLY1.2
/S1: IC2.17 (O2), RLY2.2
/S2: IC2.16 (O3), RLY3.2
/S3: IC2.15 (O4), RLY4.2
/S4: IC2.14 (O5), RLY5.2
/S5: IC2.13 (O6), RLY6.2
/S6: IC2.12 (O7), RLY7.2
/S7: IC2.11 (O8), RLY8.2
/SCK: IC1.17 ((PCINT5/SCK)PB5), P3.3, U2.12 (SCK)
/SL0: IC1.31 ((PCINT17/TXD)PD1), IC2.1 (I1)
/SL1: IC1.30 ((PCINT16/RXD)PD0), IC2.2 (I2)
/SL2: IC1.28 ((PCINT13/SCL/ADC5)PC5), IC2.3 (I3)
/SL3: IC1.27 ((PCINT12/SDA/ADC4)PC4), IC2.4 (I4)
/SL4: IC1.26 ((PCINT11/ADC3)PC3), IC2.5 (I5)
/SL5: IC1.25 ((PCINT10/ADC2)PC2), IC2.6 (I6)
/SL6: IC1.24 ((PCINT9/ADC1)PC1), IC2.7 (I7)
/SL7: IC1.23 ((PCINT8/ADC0)PC0), IC2.8 (I8)
/VCC: C1.1, IC2.10 (CD+), P1.2, RLY1.1, RLY2.1, RLY3.1, RLY4.1, RLY5.1, RLY6.1, RLY7.1, RLY8.1, U1.3 (VI)
unnamed: P2.1, U2.10 (ANA)
unnamed: P4.1, RLY1.4
unnamed: P4.2, RLY1.5
unnamed: P4.3, RLY1.3
unnamed: P5.1, RLY2.4
unnamed: P5.2, RLY2.5
unnamed: P5.3, RLY2.3
unnamed: P6.1, RLY3.4
unnamed: P6.2, RLY3.5
unnamed: P6.3, RLY3.3
unnamed: P7.1, RLY4.4
unnamed: P7.2, RLY4.5
unnamed: P7.3, RLY4.3
unnamed: P8.1, RLY5.4
unnamed: P8.2, RLY5.5
unnamed: P8.3, RLY5.3
unnamed: P9.1, RLY6.4
unnamed: P9.2, RLY6.5
unnamed: P9.3, RLY6.3
unnamed: P10.1, RLY7.4
unnamed: P10.2, RLY7.5
unnamed: P10.3, RLY7.3
unnamed: P11.1, RLY8.4
unnamed: P11.2, RLY8.5
unnamed: P11.3, RLY8.3
