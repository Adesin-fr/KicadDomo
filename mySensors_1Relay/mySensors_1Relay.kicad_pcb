# Repository Adesin-fr/KicadDomo (continued)

## KiCad design mySensors_8Relais/mySensors_8Relais.kicad_pcb (continued)

Board: 2 copper layers, 85.0 x 95.0 mm, 25 parts (1 on the bottom side), 50 nets.

## KiCad design IN16_optoToMySensors/IN16_optoToMySensors.kicad_pcb

Board: 2 copper layers, 50.0 x 50.0 mm, 13 parts (0 on the bottom side), 31 nets.

Parts:
74LS151, 74Ls151: 74LS151; SO-16-N
328p: ATMEGA328-A; TQFP-32_7x7mm_Pitch0.8mm
ANT: ANT; Pin_Header_Straight_1x01_Pitch2.54mm
C1: 10uF; R_1206_HandSoldering
ICSP: ICSP; Pin_Header_Straight_2x03
P0, P1: CONN_10; PIN_ARRAY_5x2
P3: 5VIN; bornier2
RFM69HW: RFM69HW; RFM69HW_SMD_Handsoldering
RN1, RN2: RN10K; Pin_Header_Straight_1x09_Pitch2.54mm
U4: AMS1117; SOT-223

Connections:
/5VIN: P0.3, P1.3, P3.1, U4.3
/CS: 328p.14, RFM69HW.15
/IN0: 74LS151.12, P1.1, RN2.2
/IN1: 74LS151.13, P1.2, RN2.3
/IN2: 74LS151.14, P1.4, RN2.4
/IN3: 74LS151.15, P1.6, RN2.5
/IN4: 74LS151.1, P1.7, RN2.6
/IN5: 74LS151.2, P1.8, RN2.7
/IN6: 74LS151.4, P1.9, RN2.8
/IN7: 74LS151.3, P1.10, RN2.9
/IN8: 74Ls151.12, P0.1, RN1.2
/IN9: 74Ls151.13, P0.2, RN1.3
/IN10: 74Ls151.15, P0.4, RN1.4
/IN11: 74Ls151.14, P0.6, RN1.5
/IN12: 74Ls151.1, P0.7, RN1.6
/IN13: 74Ls151.2, P0.8, RN1.7
/IN14: 74Ls151.4, P0.9, RN1.9
/IN15: 74Ls151.3, P0.10, RN1.8
/IRQ: 328p.32, RFM69HW.2
/MISO: 328p.16, ICSP.1, RFM69HW.13
/MOSI: 328p.15, ICSP.4, RFM69HW.14
/MUX1: 74Ls151.5, 328p.23
/MUX2: 74LS151.5, 328p.24
/MUXA: 74LS151.11, 74Ls151.11, 328p.25
/MUXB: 74LS151.10, 74Ls151.10, 328p.26
/MUXC: 74LS151.9, 74Ls151.9, 328p.27
/RESET: 328p.29, ICSP.5
/SCK: 328p.17, ICSP.3, RFM69HW.12
GND: 74LS151.7, 74LS151.8, 74Ls151.7, 74Ls151.8, 328p.3, 328p.5, 328p.21, C1.2, ICSP.6, P0.5, P1.5, P3.2, RFM69HW.9, RFM69HW.11, U4.1
unnamed: ANT.1, RFM69HW.10
VCC: 74LS151.16, 74Ls151.16, 328p.4, 328p.6, C1.1, ICSP.2, RFM69HW.8, RN1.1, RN2.1, U4.2

## Code that names these connections

File MySensors_8Dimmers/mySensors_8Dimmers.ino:

/**
 *
 * REVISION HISTORY
 * Version 1.0 - 24/02/2017 L. Lemarinel
 *
 * DESCRIPTION
 * This sketch is used to dim 8 Lights.
 * Each light is dimmed with a Triac.
 * Triac driving is done thru MOC3023 optocouplers
 * Each output can be controlled from the following messages :
 * 		- V_STATUS <ON/OFF> 	Toggle the light ON/OFF. If the light was previously dimmed, the previous dim level is used.
 * 		- V_PERCENTAGE <0-100> 	Set the light to the specified dim level. If the light is OFF, it will be turned ON.
 *		- V_CUSTOM 0			Triggers the default action : If the light is ON, it is switched OFF and vice-versa.
 *		- V_CUSTOM 1			Set the light ON for the amount of minutes stored in V_VAR1
 *		- V_CUSTOM 2			Begin a Dim swipe cycle : go from current dim level to 100, then go back to 0 and so on...
 *		- V_CUSTOM 3			End a dim swipe cycle : Stops on the current Dim level.
 *		- V_VAR1   <0-255>		Set the timer value
 *		- V_VAR2   <0-255>		Set the delay between two variations when changing dim value
 */

// Enable debug prints
#define MY_DEBUG

// Enable and select radio type attached
//#define MY_RADIO_NRF24
#define MY_RADIO_RFM69

#include <SPI.h>
#include <MySensors.h>

#define SN "Multi Dimable Light"
#define SV "1.0"

#define NB_LIGHT_OUTPUTS 8
#define OUTPUT_L0	PD1
#define OUTPUT_L1	PD0
#define OUTPUT_L2	PC5
#define OUTPUT_L3	PC4
#define OUTPUT_L4	PC3
#define OUTPUT_L5	PC2
#define OUTPUT_L6	PC1
#define OUTPUT_L7	PC0

#define EEPROM_TIMER_SETTING 1
#define EEPROM_DIMMER_DELAY 10

int CurrentLightState[NB_LIGHT_OUTPUTS];
int CurrentDimValue[NB_LIGHT_OUTPUTS];
int TargetDimValue[NB_LIGHT_OUTPUTS];
int TimerSetting[NB_LIGHT_OUTPUTS];
int TimerValue[NB_LIGHT_OUTPUTS];
int DimmerDelay[NB_LIGHT_OUTPUTS];
int SwipeCycleOn[NB_LIGHT_OUTPUTS];
long lastDimValueChangedTime[NB_LIGHT_OUTPUTS];

void setup(){
	//Retreive our last light state from the eprom
	for (int i=0; i< NB_LIGHT_OUTPUTS; i++){
		CurrentLightState[i]= 0;
		CurrentDimValue[i]	= 0;
		TargetDimValue[i]	= 0;
		TimerValue[i]		= 0;
		SwipeCycleOn[i]		= 0;
		TimerSetting		= loadState(EEPROM_TIMER_SETTING + i);
		DimmerDelay 		= loadState(EEPROM_DIMMER_DELAY + i);
	}

	#ifdef MY_DEBUG
		Serial.println( "Node ready to receive messages..." );
	#endif
}

void presentation() {
	// Send the Sketch Version Information to the Gateway
	sendSketchInfo(SN, SV);

	// Present all the dimmers :
	for (int i=0; i< NB_LIGHT_OUTPUTS; i++){
		present(CHILD_ID_LIGHT, S_DIMMER );
	}
}

void loop(){
	for(int i=0; i<NB_LIGHT_OUTPUTS; i++){
		// Should we change the current Dimmer Values ?
		if (CurrentLightState[i]==1 && CurrentDimValue[i] != TargetDimValue[i]){
			if (lastDimValueChangedTime[i] + (DimmerDelay[i]*100) > millis()){
				lastDimValueChangedTime[i] = millis();
				// Increment or decrement the current dimmer value :
				if (CurrentDimValue[i] > TargetDimValue[i]){
					// The current value is higher than the target, we must lower it
					CurrentDimValue[i]--;
				}else{
					// The current value is lower than the target, we must increment it
					CurrentDimValue[i]++;
				}
			}
		}
		// End of IF change dimmer values

		// Are we in a swiping cycle ? If so , we should change the target value if we reach 0 or 100 :
		// TODO : We should change the DimmerDelay temporarly to be sure we have a consistent one, and restore it at the end of the swipe cycle.
		if (SwipeCycleOn[i]==1){
			if (TargetDimValue[i]==CurrentDimValue[i] && TargetDimValue[i]=0){
				TargetDimValue[i]=100;
			}
			if (TargetDimValue[i]==CurrentDimValue[i] && TargetDimValue[i]=100){
				TargetDimValue[i]=0;
			}
		}

	} // End of FOR loop

}

void receive(const MyMessage &message){

	if (message.type == V_STATUS) {
		#ifdef MY_DEBUG
			Serial.println( "V_STATUS command received..." );
		#endif

		int lstate= atoi( message.data );
		if ((lstate!=0) && (lstate!=1)) {
			#ifdef MY_DEBUG
			Serial.println( "V_STATUS data invalid (should be 0/1)" );
			#endif
			return;
		}else{
			// Set the new state on the output :
			CurrentLightState[message.sensor] = lstate;
		}
	}
	else if (message.type == V_PERCENTAGE) {
		int dimvalue= atoi( message.data );
		if ((dimvalue<0)||(dimvalue>100)) {
			// Invalid dim value
			#ifdef MY_DEBUG
			Serial.println( "Invalid V_PERCENTAGE data received (should be 0-100)" );
			#endif
			return;
		}
		if (dimvalue==0) {
			CurrentLightState[message.sensor] = 0;
		}
		else {
			CurrentLightState[message.sensor] = 1;
			TargetDimValue[message.sensor]	  = dimvalue;
		}
	}
	else if (message.type == V_CUSTOM){

		int customAction = atoi( message.data );
		switch(customAction){
			case 0:
				// Toggle the light :
				if (CurrentLightState[message.sensor] ){
					CurrentLightState[message.sensor] = 0;
				}else{
					CurrentLightState[message.sensor] = 1;
				}
				break;
			case 1:
				// Set light ON with timer
				TimerValue[message.sensor] = TimerSetting[message.sensor];
				break;
			case 2:
				// Begin swipe cycle :
				SwipeCycleOn[message.sensor] = 1;
				break;
			case 3:
				// End swipe cycle :
				SwipeCycleOn[message.sensor] = 0;
				// TODO : restore the dimmer Delay.
				break;
		}
	}
	else if (message.type == V_VAR1){
		// Set the timer value
		int timerValue = atoi( message.data );
		// Apply the new Timer setting
		TimerSetting[message.sensor] = timerValue;
		// and save it to EEPROM
		saveState(EEPROM_TIMER_SETTING + i, timerValue);
	}
	else if (message.type == V_VAR2){
		// Set the delay between two variations when changing dim value
		int delayValue = atoi( message.data );
		// Apply the new Timer setting
		delayValue[message.sensor] = delayValue;
		// and save it to EEPROM
		saveState(EEPROM_DIMMER_DELAY + i, delayValue);
	}
	else {
		#ifdef MY_DEBUG
	    	Serial.println( "Invalid command received..." );
		#endif

		return;
	}

}

void SendCurrentState2Controller(){
	for (int i=0; i<NB_LIGHT_OUTPUTS; i++){
		if (CurrentDimValue[i] == TargetDimValue[i]){
			MyMessage dimmerMsg(i, V_DIMMER);
			send(dimmerMsg.set(CurrentDimValue[i]));
		}
	}
}

File IN16_optocoupleurs/FIRMWARE/MySensors_16IN.ino:

#define MY_RADIO_RFM69
#define MY_IS_RFM69HW
#define MY_RFM69_FREQUENCY RF69_868MHZ

#include <SPI.h>
#include <MySensors.h>

#define SKETCH_NAME "Carte 16 Entrees"
#define SKETCH_MAJOR_VER "1"
#define SKETCH_MINOR_VER "0"

#define MUX1	A0
#define MUX2	A1
#define MUXA	A2
#define MUXB	A3
#define MUXC	A4

#define SHORTPULSE 60		// Temps pour un appui court en ms
#define LONGPULSE 500		// Temps pour un appui lng en ms

// La macro suivante nous donne le nombre de valeurs dans le tableau
#define NUMBUTTONS 16

unsigned long pushTime[NUMBUTTONS];
byte pushState[NUMBUTTONS];
byte justPushed[NUMBUTTONS];
byte justReleasedShortPush[NUMBUTTONS];
byte justLongPushed[NUMBUTTONS];
byte justReleasedLongPushed[NUMBUTTONS];

#define BUTTON_STATUS_NONE 0
#define BUTTON_STATUS_PULSE_BEGIN 1
#define BUTTON_STATUS_PULSE_END 2
#define BUTTON_STATUS_HOLD_BEGIN 3
#define BUTTON_STATUS_HOLD_END 4

void setup() {
	byte i;

	// Paramétrer les pins
	pinMode(MUX1, INPUT);
	pinMode(MUX2, INPUT);
	pinMode(MUXA, OUTPUT);
	pinMode(MUXB, OUTPUT);
	pinMode(MUXC, OUTPUT);

	// Initialiser les variables
	for (i=0; i< NUMBUTTONS; i++) {
		pushTime[i]=0;
		justPushed[i]=0;
	}

}

void presentation() {
	// Send the sketch version information to the gateway and Controller
	sendSketchInfo(SKETCH_NAME, SKETCH_MAJOR_VER "." SKETCH_MINOR_VER);

	for (int numpin=0; numpin<NUMBUTTONS; numpin++){
		present(numpin, S_INFO);
	}

}

void checkPushes(){
	for (int numpin=0; numpin<NUMBUTTONS; numpin++){
		if (lirePin(numpin)==LOW){
			// Si on a pas encore enregistré d'heure d'appui, on l'enregistre.
			if (pushTime[numpin]==0){
				pushTime[numpin]=millis();
			}else{
				// On vérifie depuis combien de temps le bouton est appuyé. Si plus de SHORTPULSE alors on enregistre l'appui dans le tableau :
				if (millis() >= (pushTime[numpin]+SHORTPULSE)	&& justPushed[numpin]==0 && pushState[numpin]==BUTTON_STATUS_NONE){
					pushState[numpin]=BUTTON_STATUS_PULSE_BEGIN;
				}
				// On a deja enregistré l'etat 1, passer au 2 ?
				if (millis() >= (pushTime[numpin]+LONGPULSE)	&& pushState[numpin]==BUTTON_STATUS_PULSE_BEGIN ){
					pushState[numpin]=BUTTON_STATUS_HOLD_BEGIN;
					justLongPushed[numpin]=1;
				}
			}
		}else{
			if (pushState[numpin]==BUTTON_STATUS_HOLD_BEGIN){
				justReleasedLongPushed[numpin]=1;
			}
			if (pushState[numpin]==BUTTON_STATUS_PULSE_BEGIN){
				justReleasedShortPush[numpin]=1;
			}
			pushTime[numpin]=0;
			justPushed[numpin]=0;
			pushState[numpin]=BUTTON_STATUS_NONE;
		}
	}
}

void SendSensorStatus(byte numpin, byte actionType){

	MyMessage msg(0, V_TEXT);

	switch (actionType){
		case 1:
			send(msg.set("P"));
			break;
		case 2:
			send(msg.set("H"));
			break;
		case 3:
			send(msg.set("R"));
			break;
	}

}

void loop(){

	checkPushes();

	// Vérifier l'état de chaque broche et déclencher les evenements :
	for (int numpin=0; numpin<NUMBUTTONS; numpin++){
		if (justReleasedShortPush[numpin]==1){
			// Effacer l'evenement :
			justReleasedShortPush[numpin]=0;
			SendSensorStatus(numpin, 1);
		}

		if (justLongPushed[numpin]==1){
			// Effacer l'evenement :
			justLongPushed[numpin]=0;
			SendSensorStatus(numpin, 2);
		}

		if (justReleasedLongPushed[numpin]==1){
			// Effacer l'evenement :
			justReleasedLongPushed[numpin]=0;
			SendSensorStatus(numpin, 3);
		}
	}

}

boolean lirePin(byte numPin){

	// Définir les broches MUXA/B/C
	digitalWrite(MUXA, bitRead(numPin,0));
	digitalWrite(MUXB, bitRead(numPin,1));
	digitalWrite(MUXC, bitRead(numPin,2));

	// Attendre un peu que le mux change de broche :
	delayMicroseconds(1);

	// Lire l'entrée
	if (numPin<8){
		return digitalRead(MUX1);
	}else{
		return digitalRead(MUX2);
	}
}

File mySensors_8FilPilotes/FIRMWARE/MySensors_8FilPilote_RFM69.cpp:

/**
 *
 * REVISION HISTORY
 * Version 1.0 - 04/03/2017 L. Lemarinel
 *
 * DESCRIPTION
 * Fil pilote : 6 orders with 2 optocouplers.
 *  	each order is set with a level between 0 and 100
 *		0 to 10  : OFF
 *		11 to 20 : NO FROST
 *		21 to 30 : COMFORT - 3.5°C
 *		31 to 40 : COMFORT - 2°C
 *		41 to 50 : COMFORT - 1°C
 *		51 to 100: COMFORT

MSB FIRST :
   High Byte - Low Byte
 1  2  3  4  5  6  7  8
NP NP NP NP NP NP NP NP

 */

#define MY_DEBUG

// Enable and select radio type attached
//#define MY_RADIO_NRF24
#define MY_RADIO_RFM69
#define MY_IS_RFM69HW
#define MY_RFM69_FREQUENCY RF69_868MHZ

#include <SPI.h>
#include <MySensors.h>

#define SN 			"8 Fil Pilote"
#define SV 			"1.0"

#define NB_OUTS		8

#define SER_OUT		PC0
#define LAT_OUT		PC1 // RCLK
#define CLK_OUT		PC2	// SRCLK

byte currentMode[NB_OUTS];
byte currentPercent[NB_OUTS];
long nextUpdateTime[NB_OUTS];
byte nextUpdateStatus[NB_OUTS];

void setup(){

	pinMode( SER_OUT, OUTPUT);
	pinMode( LAT_OUT, OUTPUT);
	pinMode( CLK_OUT, OUTPUT);

	// Empty arrays :
	for (int i=0; i<NB_OUTS; i++){
		currentMode[i]=0;
		currentPercent[i]=0;
		nextUpdateTime[i]=0;
		nextUpdateStatus[i]=0;

		//Retreive our last state from the eprom
		currentPercent[i] = loadState(i);
	}

	applyState();

	#ifdef MY_DEBUG
		Serial.println( "Node ready to receive messages..." );
	#endif

}

void presentation() {
	// Send the Sketch Version Information to the Gateway
	sendSketchInfo(SN, SV);

	// Present the device :
	present(0, S_DIMMER );

}

void applyState(){

	int tempInt=0;
	byte currentMSB;
	byte currentLSB;

	for (int i=0; i<NB_OUTS; i++){
		tempInt = tempInt << 2;
		switch (currentMode[i]){
			case 1:
				tempInt |= B00000010;
				break;
			case 2:
				tempInt |= B00000001;
				break;
			case 3:
				tempInt |= B00000011;
				break;
			case 4:
				if (nextUpdateStatus[i] == 0){
					tempInt |= B00000011;
				}
				break;
			case 5:
				if (nextUpdateStatus[i] == 0){
					tempInt |= B00000011;
				}
				break;
			case 6:
				// Do nothing, we just should let it to 00 :
				// tempInt |= B00000000;
				break;
		}

	}

	currentMSB= tempInt >> 8;	// Get MSB
	currentLSB= tempInt & 0xFF; // Get LSB

	// Lock latch
	digitalWrite(LAT_OUT, LOW);
	// Write bits :
	shiftOut(SER_OUT, CLK_OUT, MSBFIRST, currentMSB);
	shiftOut(SER_OUT, CLK_OUT, MSBFIRST, currentLSB);
	// Unlock latch
	digitalWrite(LAT_OUT, HIGH);

}

void loop(){

	// check for each output to see if change is needed
	for (int i=0; i<NB_OUTS; i++){

		// Handle event type CONFORT-1 and CONFORT-2
		if (millis() >= nextUpdateTime[i] && (currentMode[i] == 4 || currentMode[i] == 5)){
			// We need to change our output status:
			if (nextUpdateStatus[i] == 1){
				// We just done 29X seconds of CONFORT, we now need to make X seconds
				if (currentMode[i] == 4){
					nextUpdateTime[i] = millis()+7000;
				}else{
					nextUpdateTime[i] = millis()+3000;
				}
				nextUpdateStatus[i] = 0;
			}else{
				if (currentMode[i] == 4){
					nextUpdateTime[i]=millis()+293000;
				}else{
					nextUpdateTime[i]=millis()+297000;
				}
				nextUpdateStatus[i]=1;
			}
			// We just changed the delays, update output :
			applyState();
		}
	}
}

void receive(const MyMessage &message){

	byte sensId = message.sensor;

	if (message.type == V_LIGHT || message.type == V_DIMMER) {
		int requestedLevel = atoi( message.data );

		#ifdef MY_DEBUG
			Serial.print( "Requested level : " );
			Serial.println( requestedLevel  );
		#endif

		requestedLevel *= ( message.type == V_LIGHT ? 100 : 1 );
		requestedLevel = requestedLevel > 100 ? 100 : requestedLevel;
		requestedLevel = requestedLevel < 0   ? 0   : requestedLevel;

		// Store current level.
		if (currentPercent[sensId] == requestedLevel){
			// Do nothing, requested level is the same that current one.
			return;
		}else{
			currentPercent[sensId] = requestedLevel;
			saveState(sensId, requestedLevel);

			if (currentPercent[sensId] <= 10){
				currentMode[sensId] = 1;
			}else if (currentPercent[sensId] > 10 and currentPercent[sensId] <= 20){
				currentMode[sensId] = 2;
			}else if (currentPercent[sensId] > 20 and currentPercent[sensId] <= 30){
				currentMode[sensId] = 3;
			}else if (currentPercent[sensId] > 30 and currentPercent[sensId] <= 40){
				// Confort - 2 : 293 + 7
				nextUpdateTime[sensId] = millis() + 293000;
				nextUpdateStatus[sensId] = 1;
				currentMode[sensId]=4;
			}else if (currentPercent[sensId] > 40 and currentPercent[sensId] <= 50){
				// Confort - 2 : 297 + 3
				nextUpdateTime[sensId] = millis() + 297000;
				nextUpdateStatus[sensId] = 1;
				currentMode[sensId] = 5;
			}else {
				// Supérieur à 51% : confort = pas de signal, 2 opto coupés
				currentMode[sensId] = 6;
			}

			applyState();
		}

	}else {
		// Do nothing
		#ifdef MY_DEBUG
	    	Serial.println( "Invalid command received..." );
		#endif

		return;
	}

}

## Commit log

2017-01-16 Premier circuit : Multiusage sur batterie 2 entrées.
2017-01-16 Ajout README.md Modification orientation support pile CR2032 Ajout d'une PULLUP sur 2eme entrée
2017-01-16 modifs
2017-01-16 Ajout des projets domotique
2017-01-17 Ajout GERBER
2017-01-17 Ajout gateway
2017-01-18 correction passerelle
2017-01-20 Ajout projet mySensors_8Relais
2017-01-20 Terminé le circuit 8 Relais
2017-01-22 Ajout module 2 relais + alimentation 220V
2017-01-24 Modifications mineures
2017-01-25 Ajout MultiUse_Battery_RFM69HCW
2017-02-26 Rename of domo_arduino_gradateur_puissance to MySensors_8Dimmers project. Added first version of MySensors_4Blinds firmware (for 8 Reed Relays board) Added pull-up resistor on radio module for 8 reed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
2017-02-28 Firmware for battery node : TwoBinarySwitches
2017-03-01 Update to MultiUse_Battery_RFM69HCW (schematic + firmware) WIP of mySensors_Teleinfo
2017-03-01 Added LMT85 Temperature sensor firmware.
2017-03-01 Update LMT85TemperatureSensor firmware
2017-03-02 Updated LMT85 Firmware Added Gateway Firmware
2017-03-03 Added ENCRYPT options to Gateway firmware
2017-03-06 Ajout firmware carte 16 Inputs
2017-03-06 FIRMWARE updates
2017-03-06 8 Dimmer FIRMWARE updated
2017-03-06 Added Fil Pilote Firmware
2017-03-06 Firmware update for Fil Pilote
2017-03-07 Added DS18B20 Firmware Added 8 Fil Pilote Firmware
2017-03-07 Firmwares Updates
2017-03-07 Added firmware for 16 Inputs board
2017-03-07 minor changes
2017-03-08 Converted this firmware to platformio project.
2017-03-08 Reorganized firmwares into an unique FIRMWARE folder. Converted every firmware to platformio projects !
2017-03-09 Firmwares updates Added uploader_flags to platformio.ini so fuses are burnt on upload
2017-03-09 Added uploader_flags to platformio.ini
2017-03-10 Changed lib folder (now uses ~/.platformio/lib "global" folder) Updated all firmwares to use new RFM69 driver which is in beta version of MySensors
2017-03-10 Added "2 Relays" firmware small changes to other firmwares.
2017-03-14 Firmware mods : Added 2 Relays + 2 Inputs Modified IN16_optoToMySensors
2017-03-15 Modifications to platformio.ini
2017-09-11 Updated scripts files
2017-09-14 Added gateway firmware
2017-09-14 Added board description in each firmware.
2017-10-20 BIG error on fuses ! Added new firmwares (water counter) Added new board
2017-10-20 Fuses correction
